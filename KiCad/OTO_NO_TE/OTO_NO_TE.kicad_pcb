# Repository yamamo2shun1/OTO_DEVICES

File README.md:

# JUMBLEQ

[Official Website](https://jumbleq.io/) · [日本語](https://jumbleq.io/ja/)

“JUMBLEQ” is short for “jumbled equipment.”

JUMBLEQ is a faderless stereo digital audio mixer that replaces the traditional channel faders found on DJ mixers with magnetic switches. The switches behave like faders while enabling a compact and unconventional control layout.

Each of the two analog stereo inputs and two USB stereo inputs can be routed to Channel Fader A, Channel Fader B, or THRU. The USB audio I/O can also be used as a send/return path, allowing a USB host device to operate as an external effects processor.

As a USB Audio Class 2.0 interface, JUMBLEQ provides 4-in/4-out audio at 24-bit, 48 kHz or 96 kHz. It is USB class-compliant and can be used with Windows, macOS, iPhone, iPad, and Android devices without a device-specific driver.

## Key Features

- Faderless mixing with 10 magnetic switches and 12 potentiometers
- Flexible stereo input routing: assign each of the two analog and two USB inputs to Channel Fader A, Channel Fader B, or THRU
- 4-in/4-out USB Audio Class 2.0 at 24-bit, 48 kHz or 96 kHz
- USB audio send/return routing for external effects processing
- USB MIDI control and the browser-based JUMBLEQ Configurator
- Built-in UF2 bootloader for drag-and-drop firmware updates

## Documentation

See the [JUMBLEQ Documentation](./Docs/README.md) for the complete documentation index.

### User Guide

- [Operation Guide](./Docs/user-guide/operation-guide.md)
- [Firmware update](./Docs/user-guide/firmware-update.md)
- [JUMBLEQ Configurator](./Docs/user-guide/configurator.md)
- [Notes for Windows users](./Docs/user-guide/windows.md)

### Technical Reference

- [Audio specifications](./Docs/reference/audio-spec.md)
- [Hardware and PCB modules](./Docs/reference/hardware.md)
- [Block diagram and audio signal flow](./Docs/reference/signal-flow.md)
- [MIDI reference](./Docs/reference/midi/README.md)

### Development

- [Development environment](./Docs/development/environment.md)
- [STM32CubeIDE projects](./STM32CubeIDE/README.md)
- [SigmaStudio+ project](./SigmaStudio+/README.md)
- [Build and UF2 generation](./Docs/development/build-and-uf2.md)
- [ST-LINK debug configuration](./STM32CubeIDE/docs/Debug_Configuration-STLINK.md)
- [J-Link debug configuration](./STM32CubeIDE/docs/Debug_Configuration-JLINK.md)
- [STM32H7S3 errata](./Docs/development/errata.md)

## Public Website

Visit the [official JUMBLEQ website](https://jumbleq.io/) for an overview of the product, its features, controls, and specifications.

The Astro source is maintained in [`Site`](./Site/) and deployed to GitHub Pages by [the Pages workflow](./.github/workflows/pages.yml).

## Repository Contents

- [`Docs`](./Docs/) — user guides, technical reference, and development notes
- [`Site`](./Site/) — Astro source for the public JUMBLEQ website
- [`STM32CubeIDE`](./STM32CubeIDE/) — MCU application, bootloader, and external memory loader projects
- [`SigmaStudio+`](./SigmaStudio+/) — ADAU1466 DSP project and exported code
- [`Max`](./Max/) — alternative Max Standalone and Max for Live versions of JUMBLEQ Configurator
- [`Plasticity`](./Plasticity/) — enclosure CAD data and printable parts
- [`Logo`](./Logo/) — JUMBLEQ logo and icon artwork
- [`UI_Design`](./UI_Design/) — panel and control-layout artwork

## Related Repositories

- [JUMBLEQ Configurator](https://github.com/yamamo2shun1/JUMBLEQ-Configurator) — browser-based JUMBLEQ Configurator

## Gallery

- [Beta Prototype](./Gallery/beta_prototype.md)
- [Alpha Prototype](./Gallery/alpha_prototype.md)
- [Functional Prototype](./Gallery/functional_prototype.md)
- [Early Prototype](./Gallery/early_prototype.md)
- [Proof of Concept](./Gallery/proof_of_concept.md)

## License

Unless otherwise noted below, this project is licensed under the [MIT License](./LICENSE.md).

- Hardware design sources in [`Plasticity`](./Plasticity/) are licensed under the [CERN Open Hardware Licence Version 2 – Permissive](./Plasticity/LICENSE) (`CERN-OHL-P-2.0`).
- Panel and control-layout design sources in [`UI_Design`](./UI_Design/) are licensed under the [CERN Open Hardware Licence Version 2 – Permissive](./UI_Design/LICENSE) (`CERN-OHL-P-2.0`).

## KiCad design KiCad/OTO_NO_TE/OTO_NO_TE.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5, C6, C7, C25, C27, C29, C31: 10nF; C_0402_1005Metric
C8, C9, C10, C11, C12, C13, C24, C26, C28, C30: C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2, J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10, RV11, RV12: 10k; RK09K1130A5R
U1, U2, U3, U4, U5, U6, U7, U9, U10, U11: DRV5056A3QDBZR; SOT-23
U8: CD74HC4067M; SOIC-24W_7.5x15.4mm_P1.27mm

Connections:
/KEY0: C8.1, J2.1, R1.2, U2.2 (OUT)
/KEY1: C9.1, J2.2, R2.2, U3.2 (OUT)
/KEY2: C10.1, J2.3, R3.2, U4.2 (OUT)
/KEY3: C11.1, J2.4, R4.2, U5.2 (OUT)
/KEY4: C12.1, J2.5, R5.2, U6.2 (OUT)
/KEY5: C13.1, J2.6, R6.2, U7.2 (OUT)
/KEY6: C24.1, R7.2, U1.2 (OUT), U8.19 (I12)
/KEY7: C26.1, R8.2, U8.18 (I13), U9.2 (OUT)
/KEY8: C28.1, R9.2, U8.17 (I14), U10.2 (OUT)
/KEY9: C30.1, R10.2, U8.16 (I15), U11.2 (OUT)
/L0: RV1.2, U8.9 (I0)
/L1: RV2.2, U8.8 (I1)
/L2: RV3.2, U8.7 (I2)
/L3: RV4.2, U8.6 (I3)
/L4: RV5.2, U8.5 (I4)
/L5: RV6.2, U8.4 (I5)
/LEDs/DIN: J3.5; also elsewhere on the board
/R0: RV7.2, U8.3 (I6)
/R1: RV8.2, U8.2 (I7)
/R2: RV9.2, U8.23 (I8)
/R3: RV10.2, U8.22 (I9)
/R4: RV11.2, U8.21 (I10)
/R5: RV12.2, U8.20 (I11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, J3.6, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, U1.3 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND), U8.12 (GND), U8.15 (~E), U9.3 (GND), U10.3 (GND), U11.3 (GND); also elsewhere on the board
unnamed: J1.2, U8.10 (S0)
unnamed: J1.3, U8.11 (S1)
unnamed: J1.4, U8.14 (S2)
unnamed: J1.5, U8.13 (S3)
unnamed: J1.6, U8.1 (COM)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C25.1, C27.1, C29.1, C31.1, J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, U1.1 (VCC), U2.1 (VCC), U3.1 (VCC), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC), U7.1 (VCC), U8.24 (VCC), U9.1 (VCC), U10.1 (VCC), U11.1 (VCC); also elsewhere on the board

Parts:
C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: 100nF; C_0402_1005Metric
ICLED1, ICLED2, ICLED3, ICLED4, ICLED5, ICLED6, ICLED7, ICLED8, ICLED9, ICLED10: 1312020030000

Connections:
/LEDs/DIN: ICLED1.3 (DIN); also elsewhere on the board
GND: C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, ICLED1.4 (VSS), ICLED2.4 (VSS), ICLED3.4 (VSS), ICLED4.4 (VSS), ICLED5.4 (VSS), ICLED6.4 (VSS), ICLED7.4 (VSS), ICLED8.4 (VSS), ICLED9.4 (VSS), ICLED10.4 (VSS); also elsewhere on the board
unnamed: ICLED1.1 (DOUT), ICLED2.3 (DIN)
unnamed: ICLED2.1 (DOUT), ICLED3.3 (DIN)
unnamed: ICLED3.1 (DOUT), ICLED4.3 (DIN)
unnamed: ICLED4.1 (DOUT), ICLED5.3 (DIN)
unnamed: ICLED5.1 (DOUT), ICLED6.3 (DIN)
unnamed: ICLED6.1 (DOUT), ICLED7.3 (DIN)
unnamed: ICLED7.1 (DOUT), ICLED8.3 (DIN)
unnamed: ICLED8.1 (DOUT), ICLED9.3 (DIN)
unnamed: ICLED9.1 (DOUT), ICLED10.3 (DIN)
VCC: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, ICLED1.2 (VDD), ICLED2.2 (VDD), ICLED3.2 (VDD), ICLED4.2 (VDD), ICLED5.2 (VDD), ICLED6.2 (VDD), ICLED7.2 (VDD), ICLED8.2 (VDD), ICLED9.2 (VDD), ICLED10.2 (VDD); also elsewhere on the board

Board: 4 copper layers, 114.3 x 85.0 mm, 77 parts (42 on the bottom side), 39 nets.

File KiCad/OTO_NO_TE/jlcpcb/production_files/BOM-OTO_NO_TE.csv:

Comment,Designator,Footprint,LCSC,Quantity
DRV5055A3xDBZxQ1,"U2,U3,U4,U5,U6,U7",SOT-23,C2152902,6
74HC4051,U1,TSSOP-16-1EP_4.4x5mm_P0.65mm,C352826,1
10nF,"C2,C3,C4,C5,C6,C7",C_0402_1005Metric,C77019,6
100nF,"C14,C15,C16,C17,C18,C19,C20,C21,C22,C23",C_0402_1005Metric,C77020,10
Conn_01x13,J1,PinHeader_1x13_P2.54mm_Vertical,,1
R_Potentiometer,RV1,RK09K1130A5R,,1
R_Potentiometer,RV8,RK09K1130A5R,,1
100nF,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
R_Potentiometer,RV4,RK09K1130A5R,,1
R_Potentiometer,RV5,RK09K1130A5R,,1
R_Potentiometer,RV3,RK09K1130A5R,,1
R_Potentiometer,RV6,RK09K1130A5R,,1
R_Potentiometer,RV2,RK09K1130A5R,,1
R_Potentiometer,RV7,RK09K1130A5R,,1
~,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C13,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C9,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,C10,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,C11,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C12,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,ICLED7,1312020030000,,1
~,ICLED10,1312020030000,,1
~,ICLED8,1312020030000,,1
~,ICLED5,1312020030000,,1
~,ICLED4,1312020030000,,1
~,ICLED2,1312020030000,,1
~,ICLED1,1312020030000,,1
~,ICLED3,1312020030000,,1
~,ICLED6,1312020030000,,1
~,ICLED9,1312020030000,,1

## KiCad design KiCad/OTO_NO_ITA/OTO_NO_ITA.kicad_pcb

Parts:
C68: 2.2uF/50V; C_0603_1608Metric
C69, C70: 560pF; C_0201_0603Metric
C71: 100nF; C_0201_0603Metric
D5: D_Schottky; D_PowerDI-123
J7, J8: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J9: UB1611-HGN; Gangyuan_UB1611-HGN; PARTREV B
Q2, Q3: STL40DN3LLH5; SON_DN3LLH5_STM
R21: 22mR; R_0603_1608Metric
R22, R24: 10k; R_0201_0603Metric
R23: 2k4; R_0201_0603Metric
U7: TCPP03-M20; QFN-20L_4.0X4.0X0.75_STM
U8: ESDA25P35-1U1M; QFN1610_STM
U9: ECMF2-40A100N6; QFN6L_ECMF2_STM

Connections:
3V3: U7.2 (VCC_VCONN); also elsewhere on the board
5V: D5.1 (K), Q3.5 (D1), Q3.6 (D1)
5V_UCPD: J8.1, Q2.5 (D1), Q2.6 (D1); also elsewhere on the board
/MCU/I2C2_SCL: U7.18 (SCL); also elsewhere on the board
/MCU/I2C2_SDA: U7.17 (SDA); also elsewhere on the board
/MCU/UCPD_CC1: U7.1 (CC1); also elsewhere on the board
/MCU/UCPD_CC2: U7.3 (CC2); also elsewhere on the board
/MCU/UCPD_INT: U7.19 (FLG_n); also elsewhere on the board
/MCU/UCPD_ISENSE: U7.4 (I_ANA); also elsewhere on the board
/MCU/UCPD_PWR_EN: U7.20 (EN); also elsewhere on the board
/MCU/USB_HS_D+: U9.6 (D+_ic); also elsewhere on the board
/MCU/USB_HS_D-: U9.5 (D-_ic); also elsewhere on the board
/USB/CC1: C70.1, J9.A5 (CC1), U7.15 (CC_1c)
/USB/CC2: C69.1, J9.B5 (CC2), U7.13 (CC_2c)
/USB/D+: J9.A6 (DP1), J9.B6 (DP2), U9.1 (D+_con)
/USB/D-: J9.A7 (DN1), J9.B7 (DN2), U9.2 (D-_con)
GND: C68.2, C69.2, C70.2, C71.2, J7.2, J8.2, J9.A1_B12 (GND), J9.B1_A12 (GND), J9.S1 (SHIELD), J9.S2 (SHIELD), J9.S3 (SHIELD), J9.S4 (SHIELD), R23.2, R24.2, U7.12 (GND), U7.21 (GND), U8.2, U9.3 (GND), U9.4 (GND); also elsewhere on the board
unnamed: D5.2 (A), J7.1
unnamed: Q2.2 (G2), Q2.4 (G1), U7.7 (GDC_g)
unnamed: Q2.1 (S2), Q2.3 (S1), U7.8 (GDC_s)
unnamed: Q3.2 (G2), Q3.4 (G1), U7.5 (GDP_g)
unnamed: Q3.1 (S2), Q3.3 (S1), U7.6 (GDP_s)
unnamed: C71.1, U7.14 (C_BIAS)
unnamed: R24.1, U7.16 (I2C_ADD)
unnamed: Q2.7 (D2), Q2.8 (D2), Q3.7 (D2), Q3.8 (D2), R21.1, U7.10 (I_SENSE)
unnamed: R22.2, R23.1, U7.11 (V_SENSE)
VBUS: C68.1, J9.A4_B9 (VBUS), J9.B4_A9 (VBUS), R21.2, R22.1, U7.9 (VBUS_c), U8.1

Notes on the sheet:
SOURCE
diff pair 90ohm
SINK

Parts:
C62, C63, C64: 4.7uF; C_0603_1608Metric
C65, C66, C67: 1uF; C_0603_1608Metric
U5: AP7361EA-33E-13; SOT-223-3_TabPin2
U6: AP2127N-1.8TRG1; SOT-23

Connections:
1V8: C66.1, C67.1, U6.2 (VO); also elsewhere on the board
3V3: C63.1, C64.1, U5.3 (VO); also elsewhere on the board
5V_UCPD: C62.1, C65.1, U5.1 (VI), U6.3 (VI); also elsewhere on the board
GND: C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, U5.2 (GND), U6.1 (GND); also elsewhere on the board

Parts:
C1, C22: 1uF; C_0402_1005Metric
C2, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C19, C23, C26, C27, C28, C29, C31, C34, C37, C38: 100nF; C_0201_0603Metric
C3, C18, C20, C24, C30: 4.7uF; C_0402_1005Metric
C4, C21, C25: 100nF; C_0402_1005Metric
C32, C33, C35, C36: 2.2uF; C_0402_1005Metric
D1, D2, D3, D4: LED; LED_0603_1608Metric
D6: D_Schottky; D_SOD-523
J1: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J2: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
J3: Conn_02x13_Odd_Even; PinSocket_2x13_P2.54mm_Vertical
J4: 15910060; PinHeader_2x03_P2.54mm_Vertical
R1, R2, R3: 10k; R_0201_0603Metric
R4: 33R; R_0201_0603Metric
R5, R6, R7, R8: 1k; R_0201_0603Metric
SW1, SW2, SW3: SKRPABE010
U1: MX25UW25645GXDI00; BGA24C100P5X5_800X600X120
U2: STM32H7S3Z8Tx; LQFP-144_20x20mm_P0.5mm
X1: 24MHz; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm

Connections:
1V8: C3.2, C4.2, C20.2, C21.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, R2.2, R3.1, U1.B4 (VCC), U1.D1 (VCCQ), U1.E4 (VCCQ), U2.45 (VDDXSPI1), U2.51 (VDDXSPI1), U2.57 (VDDXSPI1), U2.63 (VDDXSPI1); also elsewhere on the board
3V3: C1.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C22.2, C23.2, C31.2, C34.2, J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.1, R5.1, U2.3 (VBAT), U2.7 (VDD), U2.17 (VDD), U2.24 (VREFP), U2.25 (VDDA), U2.31 (VDD), U2.41 (VDD), U2.69 (VDD), U2.81 (VDD), U2.88 (VDD), U2.100 (VDD), U2.108 (VDD), U2.115 (VDD50USB), U2.116 (VDD33USB), U2.123 (VDD), U2.133 (VDD), U2.139 (VDD), X1.4 (Vcc); also elsewhere on the board
/DSP/CLKOUT: U2.87 (PC9); also elsewhere on the board
/DSP/DSP_BCLK_IN0: U2.72 (PD13); also elsewhere on the board
/DSP/DSP_BCLK_OUT0: U2.11 (PE5); also elsewhere on the board
/DSP/DSP_LRCLK_IN0: U2.71 (PD12); also elsewhere on the board
/DSP/DSP_LRCLK_OUT0: U2.10 (PE4); also elsewhere on the board
/DSP/DSP_RESET: U2.14 (PH1); also elsewhere on the board
/DSP/DSP_SDATA_IN0: U2.68 (PD11); also elsewhere on the board
/DSP/DSP_SDATA_OUT0: U2.12 (PE6); also elsewhere on the board
/DSP/USBi_MISO: U2.126 (PM14); also elsewhere on the board
/DSP/USBi_MOSI: U2.127 (PM13); also elsewhere on the board
/DSP/USBi_SCLK: U2.125 (PM11); also elsewhere on the board
/DSP/USBi_SS: U2.124 (PM12); also elsewhere on the board
/MCU/ADC1_IN0: J1.4, U2.26 (PA0)
/MCU/ADC1_IN3: J1.3, U2.34 (PA6)
/MCU/ADC1_IN5: J1.6, U2.39 (PB1)
/MCU/ADC1_IN10: J1.5, U2.18 (PC0)
/MCU/ADC1_IN12: J1.8, U2.20 (PC2)
/MCU/ADC1_IN13: J1.7, U2.21 (PC3)
/MCU/ADC1_IN15: J1.10, U2.29 (PA3)
/MCU/ADC1_IN18: U2.32 (PA4)
/MCU/DEBUG_SWCLK: J4.4, U2.96 (PA14(JTCK)
/MCU/DEBUG_SWDIO: J4.2, U2.95 (PA13(JTMS)
/MCU/ETH_MDC: J3.14, U2.19 (PC1)
/MCU/ETH_MDIO: J3.6, U2.28 (PA2)
/MCU/ETH_MII_RX_ER: J3.24, U2.73 (PB10)
/MCU/ETH_RMII_CRS_DV: J3.8, U2.35 (PA7)
/MCU/ETH_RMII_INTN: J3.20, U2.110 (PD4)
/MCU/ETH_RMII_REF_CLK: J3.4, U2.27 (PA1)
/MCU/ETH_RMII_RXD0: J3.16, U2.36 (PC4)
/MCU/ETH_RMII_RXD1: J3.18, U2.37 (PC5)
/MCU/ETH_RMII_TXD0: J3.10, U2.38 (PB0)
/MCU/ETH_RMII_TXD1: J3.12, U2.144 (PB7)
/MCU/ETH_RMII_TX_EN: J3.22, U2.74 (PB11)
/MCU/FDCAN2_RX: J2.9, U2.75 (PB12)
/MCU/FDCAN2_TX: J2.11, U2.76 (PB13)
/MCU/I2C2_SCL: J2.13, U2.90 (PA8); also elsewhere on the board
/MCU/I2C2_SDA: J2.15, U2.91 (PA9); also elsewhere on the board
/MCU/I2S3_CK: J2.12, U2.101 (PC10)
/MCU/I2S3_SDI: J2.18, U2.102 (PC11)
/MCU/I2S3_SDO: J2.16, U2.40 (PB2)
/MCU/I2S3_WS: J2.14, U2.97 (PA15(JTDI))
/MCU/LED0: R6.1, U2.106 (PD2)
/MCU/LED1: R7.1, U2.105 (PD1)
/MCU/LED2: R8.1, U2.104 (PD0)
/MCU/LPUART1_CTS: J2.8, U2.93 (PA11)
/MCU/LPUART1_RTS: J2.10, U2.94 (PA12)
/MCU/LPUART1_RX: J2.6, U2.92 (PA10)
/MCU/LPUART1_TX: J2.4, U2.143 (PB6)
/MCU/NRST: C19.2, D6.1 (K), J4.6, SW1.3 (K), SW1.4 (A), U2.15 (NRST)
/MCU/OSPI_CS: R2.1, U1.C2 (CS), U2.64 (PO0)
/MCU/OSPI_DQS: U1.C3 (DQS), U2.59 (PO2)
/MCU/OSPI_SCLK: U1.B2 (SCLK), U2.53 (PO4)
/MCU/OSPI_SIO0: U1.D3 (SIO0), U2.55 (PP0)
/MCU/OSPI_SIO1: U1.D2 (SIO1), U2.61 (PP1)
/MCU/OSPI_SIO2: U1.C4 (SIO2), U2.48 (PP2)
/MCU/OSPI_SIO3: U1.D4 (SIO3), U2.49 (PP3)
/MCU/OSPI_SIO4: U1.D5 (SIO4), U2.47 (PP4)
/MCU/OSPI_SIO5: U1.E3 (SIO5), U2.54 (PP5)
/MCU/OSPI_SIO6: U1.E2 (SIO6), U2.58 (PP6)
/MCU/OSPI_SIO7: U1.E1 (SIO7), U2.60 (PP7)
/MCU/PB5: U2.136 (PB5)
/MCU/PO1: U2.44 (PO1)
/MCU/PO5: U2.52 (PO5)
/MCU/SDMMC2_CK: J3.3, U2.130 (PD6)
/MCU/SDMMC2_CMD: J3.5, U2.131 (PD7)
/MCU/SDMMC2_D0: J3.7, U2.77 (PB14)
/MCU/SDMMC2_D1: J3.9, U2.78 (PB15)
/MCU/SDMMC2_D2: J3.11, U2.134 (PB3(JTDO)
/MCU/SDMMC2_D3: J3.13, U2.135 (PB4(NJTRST))
/MCU/SDMMC2_D4: J3.15, U2.1 (PB8)
/MCU/SDMMC2_D5: J3.17, U2.2 (PB9)
/MCU/SDMMC2_D6: J3.19, U2.84 (PC6)
/MCU/SDMMC2_D7: J3.21, U2.85 (PC7)
/MCU/UCPD_CC1: U2.111 (PM0); also elsewhere on the board
/MCU/UCPD_CC2: U2.112 (PM1); also elsewhere on the board
/MCU/UCPD_INT: U2.121 (PM8); also elsewhere on the board
/MCU/UCPD_ISENSE: U2.33 (PA5); also elsewhere on the board
/MCU/UCPD_PWR_EN: U2.122 (PM9); also elsewhere on the board
/MCU/USART3_CK: J2.7, U2.67 (PD10)
/MCU/USART3_RX: J2.5, U2.66 (PD9)
/MCU/USART3_TX: J2.3, U2.65 (PD8)
/MCU/USB_HS_D+: U2.119 (PM6); also elsewhere on the board
/MCU/USB_HS_D-: U2.118 (PM5); also elsewhere on the board
/MCU/USER_SW1: C37.2, SW2.3 (K), SW2.4 (A), U2.83 (PD15)
/MCU/USER_SW2: C38.2, SW3.3 (K), SW3.4 (A), U2.82 (PD14)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.9, J1.11, J1.12, J2.17, J2.19, J2.20, J3.23, J3.25, J3.26, J4.3, J4.5, R1.1, SW1.1, SW1.2, SW2.1, SW2.2, SW3.1, SW3.2, U1.B3 (GND), U1.C1 (VSSQ), U1.E5 (VSSQ), U2.8 (VSS), U2.16 (VSS), U2.22 (VSSA), U2.23 (VREFM), U2.30 (VSS), U2.42 (VSS), U2.46 (VSS), U2.50 (VSS), U2.56 (VSS), U2.62 (VSS), U2.70 (VSS), U2.80 (VSS), U2.89 (VSS), U2.99 (VSS), U2.107 (VSS), U2.117 (VSSUSB), U2.132 (VSS), U2.138 (VSS)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; also elsewhere on the board
MCU_DVDD: C2.2, C32.2, C33.2, C35.2, C36.2, U2.43 (VCAP1), U2.79 (VCAP2), U2.98 (VCAP3), U2.120 (DVDD), U2.137 (VCAP4)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D6.2 (A), U1.A4 (RESET)
unnamed: R3.2, U1.A5 (ECS)
unnamed: R1.2, U2.128 (BOOT0)
unnamed: R4.2, U2.13 (PH0)
unnamed: R4.1, X1.3 (OUT)
