# Repository yamamo2shun1/OTO_DEVICES (continued)

## KiCad design KiCad/OTO_NO_ITA/OTO_NO_ITA.kicad_pcb (continued)

Parts:
C39: 5.6nF; C_0201_0603Metric
C40: 150pF; C_0201_0603Metric
C41, C42, C43, C45, C48, C50, C52, C54, C56, C57, C58, C59: 100nF; C_0201_0603Metric
C44, C46, C55, C60: 10uF; C_0402_1005Metric
C47, C49, C51, C53: 10nF; C_0201_0603Metric
C61: 100nF; C_0402_1005Metric
D7: LED; LED_0603_1608Metric
J5: Conn_02x07_Odd_Even; PinSocket_2x07_P2.54mm_Vertical
J6: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
Q1: STD2805T4; TO-252-2
R9, R13, R14, R15, R16, R18, R19, R20: 33R; R_0201_0603Metric
R10, R26: 1k; R_0201_0603Metric
R11, R25: 10k; R_0201_0603Metric
R12: 4.32k; R_0201_0603Metric
R17: 100k; R_0201_0603Metric
SW4: SKRPABE010
U3: ADAU1466WBCPZ300RL; CP_72_6_ADI
U4: ADM811TARTZ; SOT-143
X2: 12.288MHz; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm

Connections:
3V3: C39.2, C40.1, C41.1, C43.1, C44.1, C45.1, C46.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.2, J5.1, J5.2, Q1.3 (E), R10.1, R25.2, U3.2 (IOVDD), U3.7 (AVDD), U3.15 (PVDD), U3.18 (IOVDD), U3.38 (IOVDD), U3.56 (IOVDD), U4.4 (VCC), X2.4 (Vcc); also elsewhere on the board
/DSP/BCLK_OUT1: J5.6, U3.43 (BCLK_OUT1)
/DSP/BCLK_OUT2: J5.5, U3.48 (BCLK_OUT2)
/DSP/CLKOUT: J5.3, J5.4, R9.2; also elsewhere on the board
/DSP/DSP_BCLK_IN0: R13.1; also elsewhere on the board
/DSP/DSP_BCLK_OUT0: R14.1; also elsewhere on the board
/DSP/DSP_LRCLK_IN0: R15.1; also elsewhere on the board
/DSP/DSP_LRCLK_OUT0: R16.1; also elsewhere on the board
/DSP/DSP_RESET: C42.1, SW4.1, SW4.2, U4.3 (~MR); also elsewhere on the board
/DSP/DSP_SDATA_IN0: R18.1; also elsewhere on the board
/DSP/DSP_SDATA_OUT0: R19.1; also elsewhere on the board
/DSP/LRCLK_OUT1: J5.8, U3.42 (LRCLK_OUT1/MP5)
/DSP/LRCLK_OUT2: J5.7, U3.47 (LRCLK_OUT2/MP8)
/DSP/MCLK: R20.2, U3.21 (XTALIN/MCLK)
/DSP/SDATA_IN1: J5.12, U3.62 (SDATA_IN1)
/DSP/SDATA_IN2: J5.11, U3.67 (SDATA_IN2)
/DSP/SDATA_OUT1: J5.10, U3.44 (SDATA_OUT1)
/DSP/SDATA_OUT2: J5.9, U3.49 (SDATA_OUT2)
/DSP/USBi_MISO: J6.3, U3.30 (MISO/SDA); also elsewhere on the board
/DSP/USBi_MOSI: J6.6, U3.32 (MOSI/ADDR1); also elsewhere on the board
/DSP/USBi_SCLK: J6.5, U3.31 (SCLKC/SCL); also elsewhere on the board
/DSP/USBi_SS: J6.7, R25.1, U3.33 (SS/ADDR0); also elsewhere on the board
/DSP/~RESET: R17.2, U3.24 (RESET*), U4.2 (~RESET)
DVDD: C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, Q1.2 (C), U3.20 (DVDD), U3.35 (DVDD), U3.53 (DVDD), U3.71 (DVDD)
GND: C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, D7.1 (K), J5.13, J5.14, J6.8, R11.1, R17.1, SW4.3 (K), SW4.4 (A), U3.1 (DGND), U3.6 (AGND), U3.14 (PGND), U3.17 (DGND), U3.19 (DGND), U3.25 (DGND), U3.36 (DGND), U3.37 (DGND), U3.54 (DGND), U3.55 (DGND), U3.72 (DGND), U3.73 (EP(GND)), U4.1 (GND), X2.2 (GND); also elsewhere on the board
unnamed: C39.1, R12.1
unnamed: D7.2 (A), R26.2
unnamed: J6.2, R26.1
unnamed: Q1.1 (B), R10.2, U3.3 (VDRIVE)
unnamed: R13.2, U3.57 (BCLK_IN0)
unnamed: R14.2, U3.40 (BCLK_OUT0)
unnamed: R9.1, U3.23 (CLKOUT)
unnamed: R15.2, U3.58 (LRCLK_IN0/MP10)
unnamed: R16.2, U3.39 (LRCLK_OUT0/MP4)
unnamed: C40.2, R12.2, U3.16 (PLLFILT)
unnamed: R18.2, U3.59 (SDATA_IN0)
unnamed: R19.2, U3.41 (SDATA_OUT0)
unnamed: R11.2, U3.34 (SELFBOOT)
unnamed: R20.1, X2.3 (OUT)

Notes on the sheet:
to USBi

Board: 6 copper layers, 73.0 x 72.0 mm, 130 parts (0 on the bottom side), 135 nets.

## KiCad design KiCad/OTO_NO_DEIRI/OTO_NO_DEIRI.kicad_pcb

Parts:
C1, C2, C3: 4.7uF; C_0603_1608Metric
C4, C5, C6, C7, C8, C9, C12, C15: 1uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C10, C13, C17: 10uF; C_0402_1005Metric
C11, C14, C18: 100nF; C_0201_0603Metric
C16, C29: 2.2uF; C_0201_0603Metric
C19, C20: 100nF; C_0402_1005Metric
C21, C22, C23, C24, C25, C26, C27, C28: open; C_1812_4532Metric_Pad1.57x3.40mm_HandSolder
D1: LED; LED_0603_1608Metric
J1: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J2, J3, J5, J6: AudioJack2_Ground; Jack_3.5mm_QingPu_WQP-PJ366ST_Vertical
J4: Conn_01x11; PinSocket_1x11_P2.54mm_Vertical
R1: 1k; R_0201_0603Metric
R2, R5, R6: 10k; R_0201_0603Metric
R3, R4, R7, R8, R9: 33R; R_0201_0603Metric
R10, R11, R12, R13: 220R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15, R16, R17: 10k; R_0201_0603Metric_Pad0.64x0.40mm_HandSolder
R18: 100k; R_0201_0603Metric
SW1: SKRPABE010
U1: AP7361EA-33E-13; SOT-223-3_TabPin2
U2: AK4619VN; AK4619VN_AKM
U3: ADM811TARTZ; SOT-143

Connections:
+3V3: C2.1, C3.1, C10.1, C11.1, C13.1, C14.1, C17.1, C18.1, C19.1, R1.1, R2.2, R5.2, R6.2, U1.3 (VO), U2.3 (TVDD), U2.18 (AVDD), U2.21 (VREFH), U3.4 (VCC)
+5V: C1.1, J1.1, U1.1 (VI)
/AIN3L: C4.1, C21.1, U2.16 (IN1P/AIN1L/AIN3L)
/AIN3R: C5.1, C22.1, U2.14 (IN2P/AIN1R/AIN3R)
/AIN3S: C4.2, C21.2, J2.S
/AIN3T: C5.2, C22.2, J2.T
/AIN6L: C6.1, C23.1, U2.12 (IN3P/AIN4L/AIN6L)
/AIN6R: C7.1, C24.1, U2.10 (IN4P/AIN4R/AIN6R)
/AIN6S: C6.2, C23.2, J3.S
/AIN6T: C7.2, C24.2, J3.T
/AOUT1L: C8.1, C25.1, U2.22 (AOUT1L)
/AOUT1R: C9.1, C26.1, U2.23 (AOUT1R)
/AOUT1S: C8.2, C25.2, R10.1, R14.2
/AOUT1T: C9.2, C26.2, R11.1, R15.2
/AOUT2L: C12.1, C27.1, U2.24 (AOUT2L)
/AOUT2R: C15.1, C28.1, U2.25 (AOUT2R)
/AOUT2S: C12.2, C27.2, R12.1, R16.2
/AOUT2T: C15.2, C28.2, R13.1, R17.2
/BCLK_OUT1: J4.4, R4.1
/I2C2_SCL: J4.10, R5.1, U2.28 (SCL/SCLK)
/I2C2_SDA: J4.9, R6.1, U2.30 (SDA/SO)
/LRCLK_OUT1: J4.5, R7.1
/MCLK: J4.2, R3.1
/PDN: R18.2, U2.26 (PDN), U3.2 (~RESET)
/RESET: C20.1, J4.11, SW1.1, SW1.2, U3.3 (~MR)
/SDATA_IN1: J4.7, R9.1
/SDATA_OUT1: J4.6, R8.1
GND: C1.2, C2.2, C3.2, C10.2, C11.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C29.2, D1.1 (K), J1.2, J2.R, J3.R, J4.1, J4.3, J4.8, J5.R, J6.R, R14.1, R15.1, R16.1, R17.1, R18.1, SW1.3 (K), SW1.4 (A), U1.2 (GND), U2.4 (VSS2), U2.19 (VSS1), U2.20 (VREFL), U2.33 (EPAD), U3.1 (GND)
unnamed: D1.2 (A), R1.2
unnamed: J5.S, R10.2
unnamed: J5.T, R11.2
unnamed: J6.S, R12.2
unnamed: J6.T, R13.2
unnamed: C16.1, U2.5 (AVDRV)
unnamed: R4.2, U2.7 (BICK)
unnamed: R2.1, U2.27 (CAD/CSN)
unnamed: R7.2, U2.6 (LRCK)
unnamed: R3.2, U2.8 (MCLK)
unnamed: R8.2, U2.1 (SDIN1)
unnamed: R9.2, U2.31 (SDOUT1)
unnamed: C29.1, U2.17 (VCOM)

Board: 4 copper layers, 58.0 x 62.0 mm, 58 parts (0 on the bottom side), 41 nets.

## Code that names these connections

File STM32CubeIDE/JUMBLEQ/JUMBLEQ.ioc (part):

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Mcu.Name=STM32H7S3Z8Tx
Mcu.Package=LQFP144
Mcu.UserName=STM32H7S3Z8Tx
PA0.GPIOParameters=PinAttribute
PA0.PinAttribute=Appli
PA0.Signal=ADCx_INP0
PA10.GPIOParameters=GPIO_Speed,PinAttribute
PA10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA10.PinAttribute=Appli
PA10.Signal=S_TIM1_CH3
PA13(JTMS/SWDIO).Mode=Serial_Wire
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=Serial_Wire
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA3.GPIOParameters=PinAttribute
PA3.PinAttribute=Appli
PA3.Signal=ADCx_INP15
PA4.GPIOParameters=PinAttribute
PA4.Mode=IN18-Single-Ended
PA4.PinAttribute=Appli
PA4.Signal=ADC1_INP18
PA5.GPIOParameters=PinAttribute
PA5.Mode=IN18-Single-Ended
PA5.PinAttribute=Appli
PA5.Signal=ADC2_INP18
PA6.GPIOParameters=PinAttribute
PA6.PinAttribute=Appli
PA6.Signal=ADCx_INP3
PA8.GPIOParameters=PinAttribute
PA8.Mode=I2C
PA8.PinAttribute=Appli
PA8.Signal=I2C3_SCL
PA9.GPIOParameters=PinAttribute
PA9.Mode=I2C
PA9.PinAttribute=Appli
PA9.Signal=I2C3_SDA
PB1.GPIOParameters=PinAttribute
PB1.PinAttribute=Appli
PB1.Signal=ADCx_INP5
PB10.GPIOParameters=PinAttribute
PB10.Mode=I2C
PB10.PinAttribute=Appli
PB10.Signal=I2C2_SCL
PB11.GPIOParameters=PinAttribute
PB11.Mode=I2C
PB11.PinAttribute=Appli
PB11.Signal=I2C2_SDA
PB12.ContextOwner=Appli
PB12.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PB12.GPIO_Label=S3
PB12.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB12.PinAttribute=Appli
PB12.Signal=GPIO_Output
PB13.ContextOwner=Appli
PB13.GPIOParameters=PinState,GPIO_Label,PinAttribute
PB13.GPIO_Label=CODEC_RESET
PB13.PinAttribute=Appli
PB13.PinState=GPIO_PIN_SET
PB13.Signal=GPIO_Output
PC0.GPIOParameters=PinAttribute
PC0.PinAttribute=Appli
PC0.Signal=ADCx_INP10
PC2.GPIOParameters=PinAttribute
PC2.PinAttribute=Appli
PC2.Signal=ADCx_INP12
PC3.GPIOParameters=PinAttribute
PC3.PinAttribute=Appli
PC3.Signal=ADCx_INP13
PC9.GPIOParameters=PinAttribute
PC9.Mode=Audio_ClockIn
PC9.PinAttribute=Free
PC9.Signal=I2S_CKIN
PD0.ContextOwner=Appli
PD0.GPIOParameters=GPIO_Label,PinAttribute
PD0.GPIO_Label=LED2
PD0.PinAttribute=Appli
PD0.Signal=GPIO_Output
PD1.ContextOwner=Appli
PD1.GPIOParameters=GPIO_Label,PinAttribute
PD1.GPIO_Label=LED1
PD1.PinAttribute=Appli
PD1.Signal=GPIO_Output
PD10.ContextOwner=Appli
PD10.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PD10.GPIO_Label=S2
PD10.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD10.PinAttribute=Appli
PD10.Signal=GPIO_Output
PD11.GPIOParameters=GPIO_Speed,PinAttribute
PD11.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PD11.Mode=SAI_A_AsyncSlave
PD11.PinAttribute=Appli
PD11.Signal=SAI2_SD_A
PD12.GPIOParameters=GPIO_Speed,PinAttribute
PD12.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PD12.Mode=SAI_A_AsyncSlave
PD12.PinAttribute=Appli
PD12.Signal=SAI2_FS_A
PD13.GPIOParameters=GPIO_Speed,PinAttribute
PD13.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PD13.Mode=SAI_A_AsyncSlave
PD13.PinAttribute=Appli
PD13.Signal=SAI2_SCK_A
PD14.ContextOwner=Appli
PD14.GPIOParameters=GPIO_Label,PinAttribute
PD14.GPIO_Label=SW2
PD14.PinAttribute=Appli
PD14.Signal=GPIO_Input
PD15.ContextOwner=Appli
PD15.GPIOParameters=GPIO_Label,PinAttribute
PD15.GPIO_Label=SW1
PD15.PinAttribute=Appli
PD15.Signal=GPIO_Input
PD2.ContextOwner=Appli
PD2.GPIOParameters=GPIO_Label,PinAttribute
PD2.GPIO_Label=LED0
PD2.PinAttribute=Appli
PD2.Signal=GPIO_Output
PD8.ContextOwner=Appli
PD8.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PD8.GPIO_Label=S0
PD8.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD8.PinAttribute=Appli
PD8.Signal=GPIO_Output
PD9.ContextOwner=Appli
PD9.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PD9.GPIO_Label=S1
PD9.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD9.PinAttribute=Appli
PD9.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Speed,PinAttribute
PE4.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE4.Mode=SAI_A_AsyncSlave
PE4.PinAttribute=Appli
PE4.Signal=SAI1_FS_A
PE5.GPIOParameters=GPIO_Speed,PinAttribute
PE5.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE5.Mode=SAI_A_AsyncSlave
PE5.PinAttribute=Appli
PE5.Signal=SAI1_SCK_A
PE6.GPIOParameters=GPIO_Speed,PinAttribute
PE6.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE6.Mode=SAI_A_AsyncSlave
PE6.PinAttribute=Appli
PE6.Signal=SAI1_SD_A
PH0-OSC_IN(PH0).Mode=HSE-DIG-External-Clock-Source
PH0-OSC_IN(PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT(PH1).ContextOwner=Appli
PH1-OSC_OUT(PH1).GPIOParameters=PinState,GPIO_Label,PinAttribute
PH1-OSC_OUT(PH1).GPIO_Label=DSP_RESET
PH1-OSC_OUT(PH1).PinAttribute=Appli
PH1-OSC_OUT(PH1).PinState=GPIO_PIN_SET
PH1-OSC_OUT(PH1).Signal=GPIO_Output
RCC.SYSCLKFreq_VALUE=600000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-01-23 I2C3割り込みよう関数追加（CubeMX生成
2026-01-23 OLED制御用のコード群を追加
2026-01-23 OLED用のコードを加えてビルドが通るように設定追加
2026-01-23 OLED用のヘッダーを追加
2026-01-23 main.cから初期化関数を各タスク内に移行
    デバッグ用変数の定義位置をUSER CODE内に移動（CubeMX生成で消されないように
2026-01-23 IOCファイルを更新
2026-01-23 OLEDに現在のGainとDry/Wetの割合を表示する
2026-01-23 OLED追加に伴い、電流値を200mAに増やす
2026-01-23 ADAU1466へのSPI送信にセマフォ/ミューテックス導入
2026-01-23 不要なデバッグ出力用コードを削除
2026-01-23 削除したヘッダーのincludeを削除
2026-01-23 電流値は余裕を持って500mAにする
2026-01-23 AK4619とADAU1466用の初期化関数とパラメータ調整関数をそれぞれ独立させる
2026-01-23 convert_pot2dB関数をpublicにする
2026-01-25 TCPP03-M20のEnableピンに繋がっているGPIOを出力Highに設定
2026-01-25 OLEDの制御を独立したタスクにする
2026-01-25 OLED用のタスクを追加
2026-01-25 I2Cで割り込みを使うの止める
2026-01-26 フォーマットをCubeMX生成時のままにする
2026-01-26 MutexとSemaphoreをCubeMXで定義する
2026-01-26 Mutex、SemaphoreはCMSIS-RTOS2 APIで使う
2026-01-26 osThreadYield()を削除
2026-01-26 FreeRTOSのヒープサイズ増加
2026-01-26 EP IN/OUTのバッファサイズを32倍に戻す（安定性優先）
2026-01-26 USBの優先度変更
2026-01-26 ADC DMAの優先度変更
2026-01-26 SAI DMAの優先度変更
2026-01-26 スタックオーバーフロー時のデバッグ変数を用意
2026-01-26 D-Cache無効化
2026-01-26 デバッグ変数増えすぎたのでいったん削除
2026-01-26 オプションバイトでDTCMを192kBに変更したので、それに合わせる
2026-01-26 スタック節約
2026-01-26 re-formatted
2026-01-28 buildフォルダ以下を無視
2026-01-29 ELFの書き込みに失敗する対策
2026-03-03 フェーダーのカーブをスクラッチ向きにしたときに正しく動作するよう修正
2026-03-03 xfade処理を段階分離し、ペア抽象化と状態集約で可読性を改善
    - xfade処理を段階関数に分離（raw/extrema/cc/pair output）
    - A/B分岐をペア定義テーブルで共通化
    - CC送信判定とDSP更新判定を分離（極値差分＋量子化差分で更新）
    - 低速操作時の取りこぼし/張り付き対策を追加（ヒステリシス＋高域再同期）
    - しきい値・指数などのマジックナンバーを定数へ集約
    - xfade関連フィールドを xfade_state_t として s_ui に集約
2026-03-03 xfade処理の命名／状態管理を整理
    - max_prev/min_prev のポインタ参照を廃止し、prev_idx + 配列で直接管理
    - prev_idx を enum 化（A/B/COUNT）
    - ペアインデックス判定を直値比較からマッピング関数ベースへ統一
    - 内部 static 関数の ui_control_ 接頭辞を整理
    - src/dst 命名を max/min に変更
    - get_pair_min_index_from_max / get_pair_max_index_from_min へ命名統一
2026-03-03 xfadeで使用している変数、関数の命名を変更
    - xfade_pair_runtime_t の max_idx/min_idx を fade_up_idx/fade_down_idx に変更
    - ペア索引関数を役割ベースへ改名
    - get_pair_fade_down_index_from_up
    - get_pair_fade_up_index_from_down
    - s_ui.xf 内の extrema 状態名を改名
    - max → up_peak
2026-03-03 コメントの文字化けを修正
2026-03-03 フェーダーカーブ調整機能を実装
    - カーブ調整モードを導入（メインOLEDを切り替えて調整する）
    - Program Change Ch.15をパラメータ調整専用とし、他は無視
    - カーブ調整モード中にControl Changeでカーブ調整を行う
    - カーブ調整値をパラメータに加え、EEPROMに保存する
2026-03-03 v0.9.2リリース
2026-03-03 MIDIの受信仕様を追加
2026-03-03 内容を修正
2026-03-03 仕様ファイルを受信と送信で分離
2026-03-03 ProgramChangeのリストを更新
2026-03-03 MIDI仕様へのリンクを追記
2026-03-03 ProgramChangeのリストを整理
2026-03-03 Maxのデバイス設定パッチを整備
2026-03-04 Parametric EQによるRIAA近似を廃止し、固定Biquadに置き換え
2026-03-04 Program Change 126で現在の設定をホスト側にダンプさせる
2026-03-04 【Max】ProgramChange 126でダンプした設定をUIに反映させる
2026-03-04 【Doc】ダンプ機能について追記
2026-03-05 Mac/iPadに接続した際に、タスクの初期化中にフリーズする不具合を修正
    - あるタスクの初期化中に別タスクの初期化が実施されないようにする
    - AUDIO、LED、ADC、OLED、USBの順で初期化を行う
2026-03-05 USB未初期化状態でAudioタスクがtud_*を触らないようにする
2026-03-05 タスクの初期化順を変更
    - OLED、LED、ADC、AUDIO、USBの順で初期化を行う
2026-03-05 USBスタック初期化前にTinyUSBの関数を呼ばないようにする
2026-03-05 Biquadフィルタ後段に2次Butterworth HPF(20Hz)を追加
2026-03-05 Butterworthの位置をBiquadの前段に変更
2026-03-05 【SigmaStudio+】RIAAの前段にButterworth 20Hz HPFを挿入
2026-03-05 メインOLEDに現在のサンプルレートを表示する
2026-03-05 v0.9.3リリース
2026-03-05 【Doc】Windowsユーザーへのコメントを追記
    - VB-Audio Matrixを追加
2026-03-05 【SigmaStudio+】USBから戻ってくる経路にVolumeブロックを追加
2026-03-06 【SigmaStudio+】USB入力用のVolumeブロックを1チャンネルごとに置く
2026-03-06 USBからのreturn用のボリューム制御関数を用意
2026-03-06 マスターボリュームを廃止し、Ch.1/2それぞれの出力ボリュームを追加
2026-03-06 アナログマルチプレクサの処理を8chから16chに変更
2026-03-06 メインOLEDの表示内容とレイアウトを変更
2026-03-06 clang-format
2026-03-06 磁気スイッチの並びを逆順にする
2026-03-06 POT12～15を磁気スイッチ系処理としてPOTと分離
2026-03-06 【Max】デバイス側のUI変更に合わせる
2026-03-06 v0.9.4リリース
2026-03-06 Update block diagram image in README
    Replaced the block diagram image with a new diagram.
2026-03-07 試作3号機の写真を追加
2026-03-07 試作2号機の写真を追加
2026-03-07 フォルダ移動
2026-03-07 試作1号機の写真を追加
2026-03-07 1ファイルから試作機ごとに分割
2026-03-07 メイン基板の写真を追加
2026-03-07 写真をrev.Cのものに差し替え
2026-03-07 ギャラリーへのリンクを追記
2026-03-07 アナログマルチプレクサの配線修正と部品番号を整理
2026-03-09 Remove kicad projects
2026-03-09 READMEからメインボードの情報を削除
    メインボードは別リポジトリに移動
2026-03-09 メインボードの写真をギャラリーから削除
2026-03-10 磁気スイッチ操作時に送信するMIDIに切り替え機能を実装
    - MIDI CCかノートを設定で切り替える（PC122/123）
    - 設定はEEPROMに保存
    - ダンプするパラメータにCC/ノートの状態も含める
2026-03-10 【Max】磁気スイッチのMIDI送信切り替えに対応
2026-03-10 【Doc】磁気スイッチ送信MIDI切り替えを追記
2026-03-10 【Max】レイアウト調整
2026-03-10 磁気スイッチのノート送信をエッジ検出ベースに変更
2026-03-10 ダンプしたパラメータがUIに正しく反映されるよう修正
2026-03-12 READMEの構成整理とハードウェア・Errata対策情報の追記
    ドキュメントの構成を分かりやすく整理するため、セクションの順序変更と「Modules」から「Hardware」への名称変更を行いました。また、STM32H7S3のエラッタ(2.2.15)に対する回避策の実装に関する情報を追加しました。
2026-03-17 CMakeでのビルドに対応
2026-03-17 表示内容に更新があった場合の再描画を行単位から画面一括に変更
2026-03-17 v0.9.5リリース
2026-03-19 Dry/WetでミックスするReturnのソースをUSB12かUSB34か切り替えるためのスイッチを追加
2026-03-19 Dry/WetでミックスするReturnソース設定の保存とMIDIでの切り替え対応とOLED表示の追加
2026-03-19 Returnソースの切り替えに対応
2026-03-19 【Max】Returnソースの切り替えに対応
2026-03-19 【Doc】Returnソースの切り替えについての説明を追記
2026-03-19 Add audio routing and signal flow diagram
    Added audio routing and signal flow diagram to README.
2026-03-20 DVS有効時にホストに送る信号にXF通過後の信号を混ぜていた不具合を修正
2026-03-20 SPIの設定をADAU1466の推奨設定に修正
2026-03-20 SPIの送信開始前にセマフォを空にする処理を追加
2026-03-20 ADAU1466にsafeloadでコマンドを送る処理を実装
    Line/Phonoの切り替えと、DVSオンオフの処理にsafeload送信を利用
2026-03-20 サンプルレート切り替え時にADAU1466を必ずリセットするよう修正
2026-03-20 XFaderで使う磁気スイッチにデッドバンドを設け、未操作時の誤動作を抑制
2026-03-20 buildフォルダをignoreリストに追加
2026-03-20 USBオーディオ処理を1ms刻みからISR通知駆動へ変更
2026-03-20 【Max】UIのレイアウト調整とコメント追記
2026-03-20 Add MIDI Configurator section with image
2026-03-20 名称修正
2026-03-20 Update image for JUMBLEQ Configurator
    Replaced the old image with a new one for the JUMBLEQ Configurator section.
2026-03-20 ignoreリストを更新
2026-03-20 【Max】ファイル名を変更
2026-03-21 JUMBLEQ Configuratorの記述を追加
2026-03-21 MIDI Specの項にJUMBLEQ Configuratorについての説明を追記
2026-03-21 Update image and Windows user instructions in README
    Updated image link in README and added a note for Windows users regarding audio drivers.
2026-03-21 Update image link in MIDI specification document
2026-03-21 オーディオのバッファサイズを縮小
2026-03-21 デバイス起動直後、XF-Aにアサインした音がフェーダーオフでも鳴ってしまう不具合を修正
2026-03-21 v0.9.6リリース
2026-03-24 UI制御関連の定数整理およびポットのマッピング修正
    - audio_control.h に定義されていたUI関連の定数を ui_control.c/h 側に移動
    - ポット用マルチプレクサのビットテーブルをインデックス順に整理し、ADC値読み取り時のチャンネル判定処理を更新
    - MAG_XFADE_RANGE の値を 850 から 1400 に調整
2026-03-24 ポット入力にヒステリシス処理を追加
    ADC値の微小な変動による値の振らつきを抑制するため、移動平均と閾値を用いたヒステリシス判定ロジックを導入しました。あわせて、移動平均の計算においてバッファが埋まる前のサンプル数も正しく扱うよう修正しています。
2026-03-24 VUメーターのdBFS計算式を修正
    SigmaDSPの8.24固定小数点形式（Unity gain = 0x01000000）に合わせてフルスケール値を修正し、対数計算を自然対数から常用対数（log10f）に変更しました。
2026-03-24 【Max】MIDI CCを受信したときにbangが点滅するようにした
2026-03-25 Enhance README with detailed JUMBLEQ features
    Expanded the description of JUMBLEQ to include details about its features and capabilities as a stereo audio mixer and USB audio interface.
2026-03-26 Update README with logo and project details
    Added a logo and improved project description.
2026-03-26 Update README to clarify JUMBLEQ description
    Removed header from README and clarified product description.
2026-03-28 Overviewセクション追加
2026-03-29 【Plasticity】筐体モデルデータを追加
2026-04-02 【Plasticity】Ignore 3D model files and Plasticity workspace
    Add *.3mf, *.stp, and the Plasticity local directory to .gitignore to prevent tracking of 3D design assets and local workspace files.
2026-04-02 【Plasticity】MAIN OLEDカバーの高さを調整
2026-04-02 OLEDの表示レイアウトをチャンネル毎から入力と出力のグループ分けに変更
    - Reorganizes the level monitoring lines to display both channel output levels together (labeled "Out") and input levels together (labeled "In").
    - Adds a percentage symbol to the dry/wet ratio display.
2026-04-02 dry/wetのPOTの最小・最大値にデッドゾーンを設ける
2026-04-02 入出力ゲイン調整のPOTアサインを変更
2026-04-02 Add prototype4.md with image references
2026-04-02 Update README with Gallery and PCB Modules section
2026-04-02 v0.9.7リリース
2026-04-06 【SigmaStudio+】SDATA_OUT2をTAD5142用に設定
    ｰ AK4619の2系統と同じ音を出力させる（仮）
2026-04-06 ビットシフト時にオーバーフローしないよう修正
    SigmaDSPのRead Blockのデータ列をuint32_tで明示的にキャストしてから扱う
2026-04-06 【Doc】HP出力追加に伴うモジュール追記
2026-04-06 HP出力更新に伴い、ブロック図を更新
2026-04-07 【SigmaStudio+】HPに出力するソース選択ブロックを追加
2026-04-07 【SigmaStudio+】生成されたヘッダーをコピー
2026-04-07 HP出力のソース切り替え関数を用意
2026-04-07 HP出力のゲイン調整関数を用意
2026-04-09 【SigmaStudio+】HP出力するソースを整理
    XF_A、XF_B、THRU、Masterの4つに変更
2026-04-09 HP出力ソース用のenumを作成し、ソース切り替え関数を置き換え
2026-04-13 SUB OLEDにヘッドホン出力設定を描画する
    （HPアイコン）M：Masterアウトをモニターする
2026-04-13 Dry/Wet調整するPOTを6から5に変更
2026-04-13 POT6にHP出力ゲイン調整を割り当てる
2026-04-13 POT操作時に設定最大値に到達しない不具合を修正
2026-04-13 MIDI ProgramChangeからのHPoutソース切り替えに対応
    - HPoutソースの設定値をEEPROMに保存
2026-04-13 【Max】HP出力ソース切り替えに対応
2026-04-13 HP出力ソース切り替えの仕様を追記
2026-04-13 SUB OLEDの最下行の描画処理をリファクタリング
2026-04-13 AK4619_Side_Module基板のThonkiconnジャック並びに合わせる
2026-04-13 POTの並びと配列の割り当ての不整合を修正
2026-04-13 変数名を修正し、OLEDの表示順を物理的な並びに合わせる
2026-04-13 POT割り当て変更に伴うOLED表示とヒステリシス処理の整合修正
2026-04-13 【Max】POT割り当て変更に合わせてUI更新
2026-04-13 Update README with new image and Windows user info
    Updated image in README and added Windows user instructions.
2026-04-13 POT定義を集約して割り当て変更を追いやすく整理
2026-04-13 v0.9.8リリース
2026-04-14 サンプルレート変更時にUIの状態を正しく反映するように修正 #71
2026-04-14 Update audio routing diagram in README
    Replaced the audio routing diagram with a new image.
2026-04-15 不要なメモを削除
2026-04-15 最小値側のデッドゾーンを少し広げる
2026-04-16 HP出力用の調整ゲイン値を取得する関数を追加
2026-04-16 MAIN OLEDの表示内容を変更
    - D/Wの値表示を削除
    - リターンソースの表示を2行目から3行目に移動し、RTNと紐付ける
    - HP出力ゲインの値表示を追加
    - 全体的な表記をブラッシュアップ
2026-04-16 Add Knob Assign section to README
    Added a new section for Knob Assign with an image.
2026-04-16 UF2書き込み完了後にリセットするよう修正
    - UF2コピー完了後のアプリ直接ジャンプをやめる
    - UF2完了または書き込み停止を検出後、少し待ってからリセットする
    - 通常起動経由で更新後アプリが起動するようにする
    - finalize処理を通さず、書き込み後の停止を回避する
2026-04-16 UF2書き込み完了後はfinalizeせずリセットするよう修正
    - UF2更新後のCRC/metadata finalize処理を廃止
    - finalize中の外部Flash Read停止を回避
    - UF2コピー完了または書き込み停止検出後に通常リセットする
    - 更新後アプリはリセット後の通常起動経由で開始する
2026-04-16 パスの修正
2026-04-16 v0.9.9リリース
2026-04-17 オーディオのルーティング図を修正
    - HP MONITOR SEL周辺をわかりやすく整理
    - 凡例を追加
2026-04-17 READMEトップのロゴ画像を差し替え
    ロゴの下に不要な背景があったため削除
2026-04-18 磁気スイッチの機能アサインについての説明画像を追加
    Added Magnetic SW Assign section and updated images.
2026-04-18 フェーダーカーブ用の指数の最大値を50から100にする
2026-04-18 【Plasticity】エンクロージャーのネジ位置調整と底面のフィレット追加
2026-04-21 MIDI CCに割り当てたPOTの最小値側デッドゾーンを調整
2026-04-21 【Max】ConfiguratorをM4L MIDIデバイス化
2026-04-21 JUMBLEQ ConfiguratorのM4Lデバイス版についての記述を追加
2026-04-21 Update README with standalone and M4L version details
    Added sections for standalone and M4L versions of JUMBLEQ Configurator with images.
2026-04-21 M4LをMax for Liveに修正
2026-04-21 【SigmaStudio+】Phono経路のゲイン調整
    - フォノEQ後に持ち上げていたゲインを+48dBから+9dBに下げる
2026-04-21 Phono選択時のゲイン調整をフォノEQ前のアナログ段で行う
    - AK4619のMIC Gain AMP Settingレジスタを使い、アナログ段でゲインを稼ぐ
2026-04-21 .stpファイルをgit LFSの管理対象にする
2026-04-21 筐体の各パーツの3Dモデルデータを追加
2026-04-21 【Plasticity】Middle Plateに補強を入れる
2026-04-22 試作段階が分かりやすいようにファイル名を変更
2026-04-22 タイトルを修正
2026-04-22 ベータ版の写真用マークダウンを追加
2026-04-22 Include images in beta prototype markdown
    Added images to the beta prototype documentation.
2026-04-22 Add Beta Prototype link to README gallery
2026-04-22 v0.9.10リリース
2026-04-22 ロゴのデザインデータを追加
2026-04-22 Top Plateのデザインデータを追加
2026-04-24 カーブ調整方式を止め、ゲート開閉方式に変更
2026-04-24 変数名を実態に沿うように変更
2026-04-24 フェーダー処理をゲート開閉方式からランプ方式に変更
2026-04-24 フェーダーを上げるときもランプで線形補間する
2026-04-25 xfadeのfade-up/down挙動を見直し保持ロジックとコメントを整理
2026-04-25 不要になった配列群を削除
2026-04-25 不要な関数とローカル変数を削除
2026-04-25 xfade状態変数と更新判定の命名を整理
2026-04-25 xfade計算まわりの変数名とロジックを整理
2026-04-25 再代入のないローカル変数をconst化
2026-04-25 fade-down底打ち後の復帰保持ロジックを改善
2026-04-27 デュアルfade-downのリトリガー処理を改善
2026-04-27 Add image to Magnetic SW Assign in README
    Added a new image for Magnetic SW Assign section.
2026-04-27 dual fade-down機能に合わせてスイッチのアサイン図を更新
2026-04-28 fade-downを離したときに音漏れが発生する不具合を修正
2026-05-01 磁気スイッチのフェーダー動作を改良
2026-05-19 xfadeスイッチのアサイン定義を一元化
    Pair A/B の fade-up、fade-down、aux fade-down を s_xfade_pairs でまとめて管理するように変更。
    逆引き、スキャン順、MIDI出力方向判定もアサイン表から導出するように整理。
2026-05-29 フェードアップのトップホールドおよびカット動作を追加
    デュアルフェードダウンジェスチャ中にフェードアップがトップ位置から離れた場合にカットする動作を導入。
2026-05-29 AK4619VNのデジタルボリュームを+2dBに設定して、Line OUTのゲインを改善
2026-05-29 Update README with audio input/output specifications
    Added specifications for line input, line output, and headphone output.
2026-05-29 HP OUTの出力ゲインをADAU1466の最終段で+2dBする
